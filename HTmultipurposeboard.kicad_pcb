# Repository yudai0804/HTmultipurposeboard

## KiCad design HTmultipurposeboard.kicad_pcb

Parts:
C1, C2, C5, C6, C7, C8, C17, C21, C22, C23, C26, C35, C36: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C9, C10, C14, C19: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11, C12, C13, C15: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C16: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18, C39: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20: 330u; CP_Radial_D8.0mm_P3.50mm
C38: 47uf; CP_Elec_6.3x5.9
C40: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2, D22, D23: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D13, D17: SR54F; D_SMB
D15, D20: D; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2, J3, J4, J11: Conn_01x03; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J13, J14: Conn_01x02; AMASS_XT60-M_1x02_P7.20mm_Vertical
Q4, Q5: BSS138; SOT-23
R1, R3: 22K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R20, R44, R58, R59: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R19, R21, R27, R28, R30, R31, R32: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R18: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R56, R57: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RGB1, RGB2: WS2812C-2020
SW1, SW3: SW_Push; TVAF06
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint_Flag; TestPoint_Pad_2.5x2.5mm
U1, U3: xh2pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
U2: ESP32-WROOM-32D; ESP32-WROOM-32
U4, U14, U18: VNH5019A-E; ST_MultiPowerSO-30
U5, U12: Si8640BB-B-IS1; SSOP-16_3.9x4.9mm_P0.635mm
U6, U7, U9: AZ1084-5.0; TO-252-2
U8: LT1963AxST-3.3; SOT-223-3_TabPin2
U10: MCWI05-12S05
U11: CH340K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm
U13: AP7375-33SA-7; SOT-23
U15: SSOP-16_3.9x4.9mm_P0.635mm

Connections:
+3.3V: C2.1, C3.1, C6.1, C15.1, C17.1, C21.1, C23.1, D1.2 (A), D2.2 (A), D22.2 (A), D23.2 (A), R1.1, R3.1, R6.1, R18.1, U2.2 (VDD), U5.1 (VDD1), U8.3 (OUT), U11.7 (VCC), U11.10 (V3), U12.1 (VDD1), U15.1 (VDD1)
+5C: C12.1, J4.2, U9.2 (VO)
+5F: C11.1, J3.2, R30.1, R31.1, R32.1, U6.2 (VO)
+5V: C1.1, C14.1, C35.1, D13.1 (K), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), RGB1.4 (VDD), RGB2.4 (VDD), U8.1 (IN)
+5VA: C13.1, J2.2, J11.2, R20.1, U7.2 (VO)
+BATT: C4.1, C9.1, C10.1, C16.1, C20.1, J14.2, R44.1, U4.3 (VCC), U4.12 (VBAT), U4.13 (VCC), U4.23 (VCC), U4.31 (VCC), U6.3 (VI), U7.3 (VI), U9.3 (VI), U13.1 (VIN), U14.3 (VCC), U14.12 (VBAT), U14.13 (VCC), U14.23 (VCC), U14.31 (VCC), U18.3 (VCC), U18.12 (VBAT), U18.13 (VCC), U18.23 (VCC), U18.31 (VCC)
BOOT: C8.1, Q5.3 (D), R18.2, SW3.2, U2.25 (IO0)
DTR: Q4.1 (G), Q5.2 (S), U11.4 (~DTR)
EN: C5.1, C36.1, Q4.3 (D), R6.2, SW1.2, U2.3 (EN)
GND: D15.1 (K), D20.1 (K)
GNDA: C4.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C20.2, J13.1, J14.1, U6.1 (GND), U7.1 (GND), U8.2 (GND), U9.1 (GND)
GNDD: C1.2, C2.2, C3.2, C5.2, C6.2, C8.2, C17.2, C18.2, C21.2, C23.2, C35.2, C36.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), R5.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R19.2, R21.2, R56.2, R57.2, RGB1.2 (GND), RGB2.2 (GND), SW1.1, SW3.1, U1.1, U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (GND), U3.1, U5.2 (GND1), U5.8 (GND1), U10.7 (-Vout), U11.3 (GND), U11.11 (GND), U12.2 (GND1), U12.8 (GND1), U15.8 (GND1)
GNDPWR: C7.2, C22.2, C26.2, C38.2, C39.2, C40.2, J2.3, J3.3, J4.3, J11.3, R9.2, R27.2, R28.2, U4.18 (GNDB), U4.19 (GNDB), U4.20 (GNDB), U4.26 (GNDA), U4.27 (GNDA), U4.28 (GNDA), U5.9 (GND2), U5.15 (GND2), U10.1 (-Vin), U12.9 (GND2), U12.15 (GND2), U14.18 (GNDB), U14.19 (GNDB), U14.20 (GNDB), U14.26 (GNDA), U14.27 (GNDA), U14.28 (GNDA), U15.9 (GND2), U18.18 (GNDB), U18.19 (GNDB), U18.20 (GNDB), U18.26 (GNDA), U18.27 (GNDA), U18.28 (GNDA)
IO25_WS2812: R15.1, U2.10 (IO25), U15.2 (A1)
IO32_WS2812: RGB1.3 (DIN), U2.8 (IO32)
I²C_SCL_IO18: U2.30 (IO18)
I²C_SDA_IO19: U2.31 (IO19)
unnamed: D1.1 (K), R2.1
unnamed: D2.1 (K), R4.1
unnamed: C18.1, D13.2 (A), U10.6 (+Vout)
unnamed: D15.2 (A), R20.2
unnamed: D17.1 (K), U10.2 (+Vin)
unnamed: D20.2 (A), R44.2
unnamed: D22.1 (K), R58.1
unnamed: D23.1 (K), R59.1
unnamed: J1.A5 (CC1), R57.1
unnamed: J1.B5 (CC2), R56.1
unnamed: RGB1.1 (DOUT), RGB2.3 (DIN)
unnamed: TP1.1, U4.1 (OUTA), U4.25 (OUTA), U4.30 (OUTA), U4.33 (OUTA)
unnamed: TP2.1, U4.15 (OUTB), U4.16 (OUTB), U4.21 (OUTB), U4.32 (OUTB)
unnamed: TP3.1, U14.1 (OUTA), U14.25 (OUTA), U14.30 (OUTA), U14.33 (OUTA)
unnamed: TP4.1, U14.15 (OUTB), U14.16 (OUTB), U14.21 (OUTB), U14.32 (OUTB)
unnamed: TP5.1, U18.1 (OUTA), U18.25 (OUTA), U18.30 (OUTA), U18.33 (OUTA)
unnamed: TP6.1, U18.15 (OUTB), U18.16 (OUTB), U18.21 (OUTB), U18.32 (OUTB)
unnamed: R9.1, U4.8 (CS)
unnamed: R30.2, U4.5 (EN/DIAGA), U4.6 (CS_DIS), U4.9 (EN/DIAGB)
unnamed: U4.4 (INA), U5.13 (B2)
unnamed: U4.10 (INB), U5.11 (B4)
unnamed: U4.7 (PWM), U5.12 (B3)
unnamed: U12.14 (B1), U18.7 (PWM)
unnamed: U12.13 (B2), U18.10 (INB)
unnamed: U12.12 (B3), U14.4 (INA)
unnamed: U12.11 (B4), U14.7 (PWM)
unnamed: C16.2, C19.2, U13.3 (GND)
unnamed: R27.1, U14.8 (CS)
unnamed: R31.2, U14.5 (EN/DIAGA), U14.6 (CS_DIS), U14.9 (EN/DIAGB)
unnamed: U5.14 (B1), U14.10 (INB)
unnamed: U15.11 (B5), U18.4 (INA)
unnamed: R28.1, U18.8 (CS)
unnamed: R32.2, U18.5 (EN/DIAGA), U18.6 (CS_DIS), U18.9 (EN/DIAGB)
RGB_OUTPUT_VCC: J11.1, U15.15 (B1)
RTS: Q4.2 (S), Q5.1 (G), U11.6 (~RTS)
RXD: R59.2, U2.34 (RXD0/IO3), U11.8 (TXD)
SERVO_1: J2.1, U15.12 (B4)
SERVO_2: J3.1, U15.13 (B3)
SERVO_3: J4.1, U15.14 (B2)
TXD: R58.2, U2.35 (TXD0/IO1), U11.9 (RXD)
USBD+: J1.A6 (D+), J1.B6 (D+), U11.1 (UD+)
USBD-: J1.A7 (D-), J1.B7 (D-), U11.2 (UD-)
VCC: C38.1, C39.1, C40.1, D17.2 (A), J13.2
Vdrive: C7.1, C19.1, C22.1, C26.1, U5.10 (EN2), U5.16 (VDD2), U12.10 (EN2), U12.16 (VDD2), U13.2 (VOUT), U15.10 (EN2), U15.16 (VDD2)
limit_1: R1.2, R2.2, U1.2, U2.7 (IO35)
limit_2: R3.2, R4.2, U2.6 (IO34), U3.2
pwm_1: R12.1, U2.28 (IO17), U12.4 (A2)
pwm_2: R11.1, U2.27 (IO16), U12.3 (A1)
pwm_3: R7.1, U2.26 (IO4), U5.4 (A2)
pwm_4: R5.1, U2.24 (IO2), U5.3 (A1)
pwm_5: R13.1, U2.11 (IO26), U12.5 (A3)
pwm_6: R8.1, U2.14 (IO12), U5.5 (A3)
pwm_7: R10.1, U2.13 (IO14), U5.6 (A4)
pwm_8: R14.1, U2.12 (IO27), U12.6 (A4)
pwm_9: R21.1, U2.9 (IO33), U15.6 (A5)
servo1: R19.1, U2.33 (IO21), U15.5 (A4)
servo2: R17.1, U2.36 (IO22), U15.4 (A3)
servo3: R16.1, U2.37 (IO23), U15.3 (A2)

Notes on the sheet:
ESP32
駆動系
リミットスイッチ
RGBLED
LED

Board: 4 copper layers, 100.0 x 60.0 mm, 103 parts (1 on the bottom side), 73 nets.

## Commit log

2024-10-08 Update fp-info-cache
2024-10-10 アホみたいにフラストレーションが溜まってるので寝る
2024-10-11 ignore update
2024-10-23 remove .DS_Store
